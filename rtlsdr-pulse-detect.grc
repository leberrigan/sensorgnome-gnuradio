options:
  parameters:
    author: Lucas Berrigan
    description: RTL-SDR Pulse detection
    generate_options: qt_gui
    id: rtlsdr_detect_pulses
    output_language: python
    title: RTL-SDR Pulse Finder
  states: {}

blocks:
- name: decimation_factor
  id: variable
  parameters:
    value: '5'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 166.38e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 24e4
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters:
    vlen: fft_size
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '3'
    max_iter: '4000'
    scale: 1/3
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import gr_detect_pulses

      blk = gr_detect_pulses.blk
    debounce_samples: '10'
    filename: '"output.csv"'
    min_snr_db: '6'
    output_type: ''
    port: ''
    pulse_len_ms: '2.5'
    samp_rate: samp_rate / decimation_factor
    verbose: ''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(64)
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation_factor
    taps: firdes.low_pass(gain=1.0,sampling_freq=240e3,cutoff_freq=30e3,transition_width=10e3,window=window.WIN_HAMMING)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '4000'
    decim: decimation_factor
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 1e4, 5e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0,bias=0"'
    bb_gain0: '20'
    freq0: freq - 4e3
    gain0: '49.6'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '100'
    xmin: '-100'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '100'
    size: '1024'
    type: float
    xmax: '0.1'
    xmin: '0.0001'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0_1
  id: qtgui_histogram_sink_x
  parameters:
    autoscale: 'False'
    bins: '100'
    size: '1024'
    type: float
    xmax: '-1'
    xmin: '-120'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: I
    label2: Q
    nconnections: '2'
    size: '1024'
    srate: samp_rate/decimation_factor
    type: float
    ymax: '0'
    ymin: '-0.0015'
  states: {state: disabled}

connections:
- [blocks_complex_to_arg_0_0, '0', epy_block_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_rms_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', epy_block_0, '1']
- [osmosdr_source_0, '0', fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
