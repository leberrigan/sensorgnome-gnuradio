options:
  parameters:
    author: Lucas Berrigan
    generate_options: qt_gui
    id: airspy_hf_detect_pulse
    output_language: python
    title: AirSpy HF+ Discovery pulse detector
  states: {}

blocks:
- name: cutoff_frequency
  id: variable
  parameters:
    value: 8e3
  states: {}
- name: decimation_factor
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 166.38e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 4e3
  states: {}
- name: max_pulse_samples
  id: variable
  parameters:
    value: int((pulse_len_ms / 1000) * (samp_rate / decimation_factor))
  states: {}
- name: pulse_len_ms
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: f"raw_iq_airspyhf_{samp_rate:.0f}.bin"
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '4000'
    scale: 1/5
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import gr_detect_pulses

      blk = gr_detect_pulses.blk
    debounce_samples: '10'
    filename: '"output.csv"'
    min_snr_db: '6'
    output_type: '''file'''
    port: '0'
    pulse_len_ms: pulse_len_ms
    samp_rate: samp_rate / decimation_factor
    verbose: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation_factor
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, cutoff_frequency, transition_width, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: soapy_airspyhf_source_0
  id: soapy_airspyhf_source
  parameters:
    center_freq: freq-freq_offset
    lna: 'True'
    maxoutbuf: '2048'
    minoutbuf: '2048'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', epy_block_0, '1']
- [soapy_airspyhf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
