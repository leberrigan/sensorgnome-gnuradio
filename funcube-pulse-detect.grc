options:
  parameters:
    author: Lucas Berrigan
    description: FUNcube pulse detection
    generate_options: no_gui
    id: funcube_detect_pulses
    output_language: python
    title: FUNcube Pulse Finder
  states: {}

blocks:
- name: cutoff_frequency
  id: variable
  parameters:
    value: 8e3
  states: {}
- name: decimation_factor
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 166.38e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 4e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"FUNcube Dongle V2.034"'
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters:
    vlen: fft_size
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: f"raw_iq_funcube_{samp_rate:.0f}.bin"
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '3'
    max_iter: '4000'
    scale: 1/3
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import gr_detect_pulses

      blk = gr_detect_pulses.blk
    debounce_samples: '10'
    filename: '"output.csv"'
    min_snr_db: '6'
    output_type: '"file"'
    port: '0'
    pulse_len_ms: '2.5'
    samp_rate: samp_rate / decimation_factor
    verbose: 'True'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(64)
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation_factor
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, cutoff_frequency, transition_width, window.WIN_HAMMING)
    type: fcc
  states: {}

connections:
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_complex_to_arg_0_0, '0', epy_block_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', epy_block_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
