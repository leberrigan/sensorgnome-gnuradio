options:
  parameters:
    author: Lucas Berrigan
    generate_options: no_gui
    id: airspy_detect_pulse
    output_language: python
    title: AirSpy pulse detector
  states: {}

blocks:
- name: cutoff_frequency
  id: variable
  parameters:
    value: 8e3
  states: {}
- name: decimation_factor
  id: variable
  parameters:
    value: '30'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 166.38e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 4e3
  states: {}
- name: max_pulse_samples
  id: variable
  parameters:
    value: int((pulse_len_ms / 1000) * (samp_rate / decimation_factor))
  states: {}
- name: pulse_len_ms
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 2e3
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: raw-iq.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: raw_iq_airspymini.bin
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: max_pulse_samples * 10
    scale: 1/10
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import sys
      sys.path.insert(0, "D:/Software/Raspberry Pi/Lucas Mods/AirSpy/gnuradio/")
      import gr_detect_pulses
      blk = gr_detect_pulses.blk
    debounce_samples: '10'
    filename: '"output.csv"'
    min_snr_db: '6'
    output_type: '"file"'
    port: '0'
    pulse_len_ms: pulse_len_ms
    samp_rate: samp_rate / decimation_factor
    verbose: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation_factor
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, cutoff_frequency, transition_width, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '2000'
    type: complex
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"airspy=0,bias=0,sensitivity=21"'
    bb_gain0: '20'
    freq0: freq - freq_offset
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '8000'
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    autoscale: 'False'
    bins: '100'
    size: '1024'
    type: float
    xmax: '-1'
    xmin: '-120'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate/5
    type: float
    ymax: '1e-1'
    ymin: '1e-4'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: freq_offset * 4
    fc: '0'
    fftsize: '1024'
    int_max: '-60'
    int_min: '-120'
    type: complex
    update_time: '0.05'
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', epy_block_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
